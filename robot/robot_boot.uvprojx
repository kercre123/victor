# Keil uVision project robot_boot.uvprojx, settings and files
target robot (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MK02FN128xxx10 Freescale
  pack: Keil.Kinetis_K00_DFP.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x02000) IRAM2(0x1FFFE000,0x02000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robot_boot +hex
  AfterMake: fromelf --bin build\boot\robot_boot.axf --output binaries\robot_boot.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: COZMO_ROBOT,COZMO_ROBOT_V41,ROBOT_HARDWARE,CORETECH_ROBOT,DEBUG, CPU_MK02FN128VLH10, KEIL, FRDM_K22F120M, FREEDOM
  c misc: --library_type=standardlib --diag_suppress=1296,186 
 --library_interface=armcc  
--gnu
  c include: k02_hal/lib;include;k02_hal;../crypto;./sideload
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  link misc: --remove 
--predefine="-D__stack_size__=0x1800" 
--predefine="-D__heap_size__=0x400"
  group boot
    ./boot/: fconf.cpp main.cpp power.cpp recovery.cpp spi.cpp timer.cpp uart.cpp
    ../crypto/: crc32.cpp
  group startup
    ./boot_startup/: system_MK02F12810.c startup_MK02F12810.s
software components: CMSIS:CORE 4.1.0
