# Keil uVision project robot21.uvprojx, settings and files
target robot (ARM-ADS)
  device: STM32F427IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robot
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_DEFAULT_TIMEOUT_CALLBACK,USE_EMBEDDED_PHY,USE_USB_OTG_FS,COZMO_ROBOT,ROBOT_HARDWARE,CORETECH_ROBOT,COZMO2,COZMO_ROBOT_V32
  c misc: --asm
  c include: .\arm_oldhal;.\arm_oldhal\lib;..\include;..\coretech\common\include;..\coretech\messaging\include;..\coretech\planning\include;..\coretech\vision\include;.\supervisor\src;..\..\coretech-external\heatshrink;C:\Keil\ARM\Pack\ARM\CMSIS\3.20.4\Device\ARM\ARMCM4\Include;.\include;..\tools\anki-util\source\anki
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\robot.sct
  group hal
    ./arm_oldhal/hal/: frontCamera.cpp imu.cpp lights.cpp main.cpp motors.cpp retarget.cpp spi.cpp startup.cpp timer.cpp uart.cpp usb_radio.cpp system_stm32f4xx.c
    ./arm_hal/hal/: blocks.cpp battery.cpp enjpeg.cpp
    ./supervisor/src/: backpackLightController.cpp ledController.cpp
  group lib
    ./arm_oldhal/lib/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group startup
    ./arm_oldhal/startup/: startup_stm32f429_439xx.s
  group supervisor
    ./supervisor/src/: cozmoBot.cpp dockingController.cpp gripController.cpp headController.cpp liftController.cpp localization.cpp messages.cpp pathFollower.cpp pickAndPlaceController.cpp speedController.cpp steeringController.cpp testModeController.cpp wheelController.cpp imuFilter.cpp animationController.cpp eyeController.cpp animation.cpp keyFrame.cpp
  group coretech-common
    ../coretech/common/robot/src/: comparisons.cpp compress.cpp decisionTree.cpp draw.cpp errorHandling.cpp find.cpp fixedLengthList.cpp flags.cpp geometry.cpp interpolate.cpp matlabInterface.cpp matrix.cpp opencvLight.cpp sequences.cpp serialize.cpp trig_fast.cpp utilities.cpp utilities_c.c memory.cpp
    ../coretech/common/shared/src/: radians.cpp utilities_shared.cpp velocityProfileGenerator.cpp matlabConverters.cpp
  group coretech-planning
    ../coretech/planning/shared/src/: path.cpp
  group embedded-tests
    ./test/: embeddedCommonTests.cpp embeddedTests.cpp embeddedTests.h embeddedVisionTests.cpp run_m4_embeddedTests.cpp
  group anki-util
    ../tools/anki-util/source/anki/embedded/transport/: reliableTransport.c
    ../tools/anki-util/source/anki/util/transport/: reliableSequenceId.cpp reliableMessageTypes.cpp
target embedded-tests (ARM-ADS)
  device: STM32F429NI STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: robot
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_DEFAULT_TIMEOUT_CALLBACK,USE_EMBEDDED_PHY,USE_USB_OTG_FS,COZMO_ROBOT,ROBOT_HARDWARE,ANKICORETECH_EMBEDDED_USE_HEATSHRINK,CORETECH_ROBOT
  c misc: --asm
  c include: .\arm_oldhal;.\arm_oldhal\lib;..\include;..\coretech\common\include;..\coretech\messaging\include;..\coretech\planning\include;..\coretech\vision\include;.\supervisor\src;..\..\coretech-external\heatshrink;C:\Keil\ARM\Pack\ARM\CMSIS\3.20.4\Device\ARM\ARMCM4\Include;.\include
  memory RVCT4: ROM 0x0 size 0xa
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\robot.sct
