# Keil uVision project fixture.uvproj, settings and files
target Release (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: fixture
  BeforeMake: cmd /c del build\binaries.o
  AfterMake: fromelf --bin build\fixture.axf --output build\fixture.bin
  AfterMake: ..\crypto\Release_FIXTURE\makesafe_fixture -prod fixture.safe build\fixture.bin
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS,FIXTURE
  c misc: --exceptions --exceptions_unwind
  c include: lib;hal;usb;.
  asm define: FIXTURE_MAIN
  asm misc: --cpreproc
  memory RVCT4: ROM 0x8060000 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\fixture.sct
  link misc: --datacompressor off
  group lib
    ./lib/: misc.c stm32f2xx_adc.c stm32f2xx_crc.c stm32f2xx_dac.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group fixture
    ./app/: app.c binaries.s bodyTest.c cubeTest.c headTest.c robotTest.c
  group hal
    ./hal/: board.c system_stm32f2xx.c startup_stm32f2xx.s stm32fxxx_it.c swd.c timers.c uart.c display.c flash.c console.c monitor.c espressif.c cube.c testport.c
  group crypto
    ../crypto/: opensafe.c
target FCC (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: as above
  output: fixture-fcc
  BeforeMake: cmd /c del build\binaries.o
  AfterMake: fromelf --bin build\fcc\fixture-fcc.axf --output build\fixture-fcc.bin
  AfterMake: ..\crypto\Release_FIXTURE\makesafe_fixture -prod fixture.safe build\fixture-fcc.bin
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: FCC,USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS,FIXTURE
  c misc: --exceptions --exceptions_unwind
  c include: lib;hal;usb;.
  asm misc: --cpreproc --cpreproc_opts=-DFCC=1
  memory RVCT4: ROM 0x8060000 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\fixture.sct
  link misc: --datacompressor off
