# Keil uVision project nrf51.uvproj, settings and files
target nrf51 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51.out +hex
  AfterMake: fromelf --bin nrf51\build\nrf51.out --output ..\releases\nrf51_stub.bin
  c flags: Optim=3 oTime=1 OneElfS=1
  c define: NRF51,COZMO_ROBOT
  c misc: -DROBOT41
  c include: .\nrf51\Include;.\nrf51\Include\app_common;.\nrf51\Include\ble;.\nrf51\Include\ble\ble_services;.\nrf51\Include\ble\rpc;.\nrf51\Include\gcc;..\..\include;..\..\coretech\common\include;..\supervisor\src;..\include;..\nrf51;..\nrf51\common
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\nrf51\scatter.scf
  group main
    ./nrf51/: main.cpp
  group nrf51
    ./nrf51/: system_nrf51.c startup_nrf51.s
