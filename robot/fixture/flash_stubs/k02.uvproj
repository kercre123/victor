# Keil uVision project k02.uvproj, settings and files
target k02_stub (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: k02_stub.out +hex
  AfterMake: fromelf --bin k02\build\k02_stub.out --output ..\releases\k02_stub.bin
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: CPU_MK02FN128VLH10
  c include: .;supervisor/src;../coretech/common/include;../coretech/vision/include;../include;include;k02/lib;k02/;k02/startup;generated/clad/k02_stub/
  library: MicroLIB
  scatter file: .\k02\scatter.scf
  group startup
    k02/startup/: startup_MK02F12810.s system_MK02F12810.c
  group main
    ./k02/: main.cpp
