# Keil uVision project systest.uvprojx, settings and files
target REVG (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: systest +hex
  BeforeMake: cmd /c del build\systest.bin
  AfterMake: fromelf --bin build\revd\systest.axf --output build\systest.bin
  AfterMake: cmd /c copy build\systest.bin ..\releases
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SYSCON,HWVER_REVG,STM32F030xC,USE_STDPERIPH_DRIVER,DEBUG
  c misc: --gnu
  c include: include;hal;syscon;stm32f0xx;../common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ./: main.cpp cmd.cpp
    ./hal/: board.cpp
  group stm32f0xx
    ./stm32f0xx/: stm32f0xx_adc.c stm32f0xx_tim.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group hal
    ./hal/: system_stm32f0xx.c startup_stm32f030xc.s hal_delay.c
  group common
    ../common/: systest.h contacts.cpp timer.cpp
  group syscon
    ./syscon/: opto.cpp i2c.cpp
software components: CMSIS:CORE 5.0.1
