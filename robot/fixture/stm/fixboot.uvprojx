# Keil uVision project fixboot.uvprojx, settings and files
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F207IG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: boot +hex
  AfterMake: fromelf --bin build\boot\boot.axf --output build\boot\boot.bin
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS
  c misc: --c99
  c include: stm32f2xx;hal;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group lib
    ./stm32f2xx/: misc.c stm32f2xx_adc.c stm32f2xx_crc.c stm32f2xx_dac.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group boot
    ./boot/: app.c
  group hal
    ./hal/: system_stm32f2xx.c
  group startup
    ./boot/: startup_stm32f2xx.s
software components: CMSIS:CORE 5.4.0
