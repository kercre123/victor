# Keil uVision project fixture.uvprojx, settings and files
target Release (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fixture
  BeforeMake: cmd /c del build\startup_stm32f2xx.o
  AfterMake: fromelf --bin build\fixture.axf --output build\fixture.bin
  AfterMake: ..\crypto\Release_FIXTURE\makesafe_fixture -prod fixture.safe build\fixture.bin
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_FS,FIXTURE
  c misc: --exceptions --exceptions_unwind
  c include: lib;hal;usb;.
  asm define: FIXTURE_MAIN
  memory RVCT4: ROM 0x80a0000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group lib
    ./hal/: stm32fxxx_it.c system_stm32f2xx.c startup_stm32f2xx.s
    ./lib/: misc.c stm32f2xx_adc.c stm32f2xx_crc.c stm32f2xx_dac.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group fixture
    ./app/: app.c pcbTest.c binaries.s
  group hal
    ./hal/: board.c swd.c timers.c testport.c uart.c display.c flash.c console.c monitor.c espressif.c cube.c
  group crypto
    ../crypto/: opensafe.c
software components: CMSIS:CORE 4.1.0
