# Keil uVision project cubeotp.uvprojx, settings and files
target DVT3-B (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: cubeotp +hex
  BeforeMake: cmd /c del cubeotp.bin
  AfterMake: fromelf --bin build\cubeotp.axf --output cubeotp.bin
  c flags: Optim=4 uC99=1 wLevel=2
  c define: DEBUG,HWVERDVT3B
  c misc: --thumb -c
  c include: .;
.\flash_programmer;
.\releases;
..\hal;
..\hal\ontogeny;
..\sdk_da1458x\5.0.4\sdk\platform\arch;
..\sdk_da1458x\5.0.4\sdk\platform\arch\compiler\rvds;
..\sdk_da1458x\5.0.4\sdk\platform\arch\ll\rvds;
..\sdk_da1458x\5.0.4\sdk\platform\driver\adc;
..\sdk_da1458x\5.0.4\sdk\platform\driver\reg;
..\sdk_da1458x\5.0.4\sdk\platform\include;
..\sdk_da1458x\5.0.4\sdk\platform\driver\gpio;
..\sdk_da1458x\5.0.4\sdk\app_modules\api;
..\sdk_da1458x\5.0.4\sdk\platform\driver\uart
  library: MicroLIB
  scatter file: startup\peripheral_examples.sct
  group app
    ./: main.c cmd.c otp.c
    ./releases/: binaries.s
  group hal_draft
    ../hal/ontogeny/: hal_timer.c hal_timer_stub.c
  group hal_release
    ../hal/: board.c vbat.h hal_uart.c console.c console_optimized.c bdaddr.c
  group sdk drivers
    ../sdk_da1458x/5.0.4/sdk/platform/driver/adc/: adc.c
    ../sdk_da1458x/5.0.4/sdk/platform/driver/gpio/: gpio.c
  group startup
    ./startup/: boot_vectors.s system_ARMCM0.c per_ex_hard_fault.c peripheral_examples.sct sysram.ini
  group flash_programmer
    ./flash_programmer/: otpc.c crc32.c
