# Keil uVision project cubetest.uvprojx, settings and files
target DVT3-B (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: cubetest +hex
  BeforeMake: cmd /c del cubetest.bin
  AfterMake: fromelf --bin build\cubetest.axf --output cubetest.bin
  c flags: Optim=1 uC99=1 wLevel=2
  c define: DEBUG, HWVERDVT3B
  c misc: --thumb -c
  c include: .;
..\hal;
..\hal\ontogeny;
..\sdk_da1458x\5.0.4\sdk\platform\arch;
..\sdk_da1458x\5.0.4\sdk\platform\arch\compiler\rvds;
..\sdk_da1458x\5.0.4\sdk\platform\arch\ll\rvds;
..\sdk_da1458x\5.0.4\sdk\platform\driver\adc;
..\sdk_da1458x\5.0.4\sdk\platform\driver\reg;
..\sdk_da1458x\5.0.4\sdk\platform\include;
..\sdk_da1458x\5.0.4\sdk\platform\driver\gpio;
..\sdk_da1458x\5.0.4\sdk\app_modules\api;
..\sdk_da1458x\5.0.4\sdk\platform\driver\uart
  library: MicroLIB
  scatter file: startup\peripheral_examples.sct
  group app
    ./: main.c cmd.c leds.c
  group hal
    ../hal/: board.c vbat.h hal_uart.c console.c
  group hal_draft
    ../hal/ontogeny/: hal_timer.c hal_spi.c accel.c hal_led_v21.c
  group sdk drivers
    ../sdk_da1458x/5.0.4/sdk/platform/driver/adc/: adc.c
    ../sdk_da1458x/5.0.4/sdk/platform/driver/gpio/: gpio.c
  group startup
    ./startup/: boot_vectors.s system_ARMCM0.c per_ex_hard_fault.c peripheral_examples.sct sysram.ini
