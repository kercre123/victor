# Keil uVision project prod_test_anki_cube.uvprojx, settings and files
target prod_test_580 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: prod_test_anki_cube +hex
  AfterMake: fromelf --bincombined --output=".\out_580\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c misc: --c99 --thumb -c --preinclude da1458x_config_basic.h --preinclude da1458x_config_advanced.h --preinclude app_audio439_config.h
  c include: .\..\;.\..\..\..\..\..\sdk\platform\include;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\sdk\platform\arch\boot\rvds;.\..\..\..\..\..\sdk\platform\arch\ll\rvds;.\..\..\..\..\..\sdk\platform\driver\reg;.\..\..\..\..\..\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk\platform\driver\led;.\..\..\..\..\..\sdk\platform\driver\systick;.\..\..\..\..\..\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk\platform\driver\emi;.\..\..\..\..\..\sdk\platform\driver\uart;.\..\..\..\..\..\sdk\platform\driver\flash;.\..\..\..\..\..\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk\ble_stack\hcic;.\..\..\..\..\..\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk\platform\driver\adc;.\..\..\..\..\..\sdk\platform\driver\pwm;.\..\..\..\..\..\sdk\platform\driver\spi;.\..\..\..\..\..\sdk\platform\driver\spi_439;.\..\..\..\..\..\sdk\app_modules\api;.\..\src;.\..\src\system;.\..\src\config;.\..\..\..\..\..\sdk\platform\arch\main;.\..\..\..\..\..\sdk\platform\driver\intc;.\..\..\..\..\..\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk\common_project_files;.\..\..\..\..\..\..\..\hal;.\..\..\..\..\..\..\..\hal\ontogeny
  library: MicroLIB
  scatter file: .\..\..\..\..\..\sdk\common_project_files\scatterfiles\scatterfile_prodtest_580.sct
  link misc: .\..\..\..\..\..\sdk\common_project_files\misc\rom_symdef_prodtest.txt  --symdefs=prod_test_580_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
  group boot
    ./../../../../../sdk/platform/arch/boot/rvds/: system_ARMCM0.c boot_vectors.s
  group arch
    ./../../../../../sdk/platform/arch/main/: arch_main.c jump_table.c nmi_handler.c arch_sleep.c hardfault_handler.c arch_system.c arch_patch.c
    ./../src/system/: user_periph_setup.c
  group patches
    ./../../../../../sdk/platform/patch_code/DA14580/obj/: atts_task.obj ch_map.obj gapm_util.obj ke_task.obj smpc.obj smpc_task.obj llc.obj ke_mem.obj gapc_task.obj llc_con_update_ind.obj
    ../../../../../sdk/platform/patch_code/DA14580/obj/: atts_util.obj
  group patches_581
    ../../../../../sdk/platform/patch_code/DA14581/obj/: atts_util.obj lld.obj llm_task.obj smpc_task.obj ke_mem.obj ke_task.obj
    ./../../../../../sdk/platform/patch_code/DA14581/obj/: gapc_task.obj llc_con_update_ind.obj
  group driver
    ./../../../../../sdk/platform/driver/syscntl/: syscntl.c
    ./../../../../../sdk/platform/core_modules/rf/src/: rf_580.c
    ./../../../../../sdk/platform/driver/adc/: adc.c
    ./../../../../../sdk/platform/driver/gpio/: gpio.c
    ./../../../../../sdk/platform/driver/pwm/: pwm.c
    ./../../../../../sdk/platform/driver/spi/: spi.c
    ./../../../../../sdk/platform/driver/spi_439/: spi_439.c
    ../../../../../sdk/platform/driver/trng/: trng.c
  group host
    ./../../../../../sdk/ble_stack/host/gap/gapm/: gapm.c
  group nvds
    ./../../../../../sdk/platform/core_modules/nvds/src/: nvds.c
  group rwble
    ./../../../../../sdk/ble_stack/rwble/: rwble.c
    ./../../../../../sdk/platform/core_modules/rwip/src/: rwip.c
  group app
    ../src/: customer_prod.c custom_lld_evt.c custom_lld_data.c custom_lld.c custom_gtl_eif.c custom_gtl_hci.c xtal_cal.c pulse.s rdtest_api.c rdtest_lowlevel.c rdtest_support.c app_audio_codec.c app_audio439.c audio_test.c audio_task.c
    ../src/system/: mainloop_callbacks.c
  group anki
    ../: anki_hook.c
    ../../../../../../../hal/: board.c
target prod_test_581 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: prod_test_581 +hex
  AfterMake: fromelf --bincombined --output=".\out_581\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14581__
  c misc: as above
  c include: .\..\;.\..\..\..\..\..\sdk\platform\include;.\..\..\..\..\..\sdk\platform\arch;.\..\..\..\..\..\sdk\platform\arch\compiler\rvds;.\..\..\..\..\..\sdk\platform\arch\boot\rvds;.\..\..\..\..\..\sdk\platform\arch\ll\rvds;.\..\..\..\..\..\sdk\platform\driver\reg;.\..\..\..\..\..\sdk\platform\core_modules\common\api;.\..\..\..\..\..\sdk\platform\core_modules\dbg\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\api;.\..\..\..\..\..\sdk\platform\core_modules\gtl\src;.\..\..\..\..\..\sdk\platform\core_modules\ke\api;.\..\..\..\..\..\sdk\platform\core_modules\ke\src;.\..\..\..\..\..\sdk\platform\core_modules\nvds\api;.\..\..\..\..\..\sdk\platform\core_modules\rf\api;.\..\..\..\..\..\sdk\platform\core_modules\rwip\api;.\..\..\..\..\..\sdk\ble_stack\rwble;.\..\..\..\..\..\sdk\ble_stack\controller\em;.\..\..\..\..\..\sdk\ble_stack\controller\llc;.\..\..\..\..\..\sdk\ble_stack\controller\lld;.\..\..\..\..\..\sdk\ble_stack\controller\llm;.\..\..\..\..\..\sdk\platform\driver\led;.\..\..\..\..\..\sdk\platform\driver\systick;.\..\..\..\..\..\sdk\platform\driver\syscntl;.\..\..\..\..\..\sdk\platform\driver\emi;.\..\..\..\..\..\sdk\platform\driver\uart;.\..\..\..\..\..\sdk\platform\driver\flash;.\..\..\..\..\..\sdk\platform\driver\gpio;.\..\..\..\..\..\sdk\ble_stack\host\att;.\..\..\..\..\..\sdk\ble_stack\host\att\attc;.\..\..\..\..\..\sdk\ble_stack\host\att\attm;.\..\..\..\..\..\sdk\ble_stack\host\gap;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapc;.\..\..\..\..\..\sdk\ble_stack\host\gap\gapm;.\..\..\..\..\..\sdk\ble_stack\host\att\atts;.\..\..\..\..\..\sdk\ble_stack\host\gatt;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattc;.\..\..\..\..\..\sdk\ble_stack\host\gatt\gattm;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cc;.\..\..\..\..\..\sdk\ble_stack\host\l2c\l2cm;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpc;.\..\..\..\..\..\sdk\ble_stack\host\smp\smpm;.\..\..\..\..\..\sdk\ble_stack\rwble_hl;.\..\..\..\..\..\sdk\ble_stack\hcic;.\..\..\..\..\..\sdk\ble_stack\host\smp;.\..\..\..\..\..\sdk\platform\driver\adc;.\..\..\..\..\..\sdk\platform\driver\pwm;.\..\..\..\..\..\sdk\platform\driver\spi;.\..\..\..\..\..\sdk\platform\driver\spi_439;.\..\..\..\..\..\sdk\app_modules\api;.\..\src;.\..\src\system;.\..\src\config;.\..\..\..\..\..\sdk\platform\arch\main;.\..\..\..\..\..\sdk\platform\driver\intc;.\..\..\..\..\..\sdk\platform\core_modules\arch_console;.\..\..\..\..\..\sdk\ble_stack\profiles;.\..\..\..\..\..\sdk\common_project_files
  library: MicroLIB
  scatter file: .\..\..\..\..\..\sdk\common_project_files\scatterfiles\scatterfile_prodtest_581.sct
  link misc: .\..\..\..\..\..\sdk\common_project_files\misc\rom_symdef_prodtest_581.txt  --symdefs=prod_test_581_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
target prod_test_583 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0
  cpu: as above
  output: prod_test_583 +hex
  AfterMake: fromelf --bincombined --output=".\out_583\@L.bin"  "!L"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: __DA14583__
  c misc: as above
  c include: as above
  library: MicroLIB
  scatter file: as above
  link misc: .\..\..\..\..\..\sdk\common_project_files\misc\rom_symdef_prodtest.txt  --symdefs=prod_test_583_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*)  --keep nvds.o(*) --any_placement=best_fit --datacompressor off
