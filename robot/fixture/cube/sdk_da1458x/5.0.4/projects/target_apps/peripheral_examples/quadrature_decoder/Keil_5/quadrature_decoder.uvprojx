# Keil uVision project quadrature_decoder.uvprojx, settings and files
target quadrature_decoder (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: quadrature_decoder +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c misc: --thumb -c
  c include: ..\include;..\..\..\..\..\sdk\platform\arch;..\..\..\..\..\sdk\platform\arch\compiler\rvds;..\..\..\..\..\sdk\platform\arch\ll\rvds;..\..\..\..\..\sdk\platform\driver\reg;..\..\..\..\..\sdk\platform\include;..\..\..\..\..\sdk\platform\driver\gpio;..\..\..\..\..\sdk\app_modules\api;..\..\..\..\..\sdk\ble_stack\rwble_hl\rwble_hl;..\..\shared\common_uart;..\..\..\..\..\sdk\platform\driver\uart;..\..\..\..\..\sdk\platform\driver\wkupct_quadec;..\..\..\..\..\sdk\platform\driver\syscntl
  library: MicroLIB
  scatter file: ..\..\shared\peripheral_examples.sct
  group boot
    ../../shared/startup/: boot_vectors.s system_ARMCM0.c per_ex_hard_fault.c
  group driver
    ../../../../../sdk/platform/driver/gpio/: gpio.c
    ../../../../../sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ../../../../../sdk/platform/driver/uart/: uart2.c
    ../../../../../sdk/platform/driver/syscntl/: syscntl.c
  group common_uart
    ../../shared/common_uart/: common_uart.c
  group app
    ../src/: main.c user_periph_setup.c
