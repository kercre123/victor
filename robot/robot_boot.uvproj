# Keil uVision project robot_boot.uvproj, settings and files
target robot (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: robot_boot +hex
  AfterMake: fromelf --bin build\robot_boot.axf --output build\robot_boot.bin
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: COZMO_ROBOT,COZMO_ROBOT_V41,ROBOT_HARDWARE,CORETECH_ROBOT,DEBUG, CPU_MK02FN128VLH10, KEIL, FRDM_K22F120M, FREEDOM
  c misc: --library_type=standardlib --diag_suppress=1296,186 
 --library_interface=armcc  
--gnu
  c include: k02_hal/lib;include;k02_hal
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  link misc: --remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x400"
  group boot
    ./boot/: crc32.cpp fconf.cpp main.cpp power.cpp recovery.cpp spi.cpp timer.cpp uart.cpp
  group startup
    ./boot_startup/: system_MK02F12810.c startup_MK02F12810.s
