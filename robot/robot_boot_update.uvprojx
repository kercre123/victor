# Keil uVision project robot_boot_update.uvprojx, settings and files
target robot (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MK02FN128xxx10 Freescale
  pack: Keil.Kinetis_K00_DFP.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x02000) IRAM2(0x1FFFE000,0x02000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robot_boot_update
  AfterMake: python tools\boot_header.py build\robot_boot_update\robot_boot_update.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: TARGET_K02,COZMO_ROBOT,COZMO_ROBOT_V41,ROBOT_HARDWARE,CORETECH_ROBOT,DEBUG, CPU_MK02FN128VLH10, KEIL, FRDM_K22F120M, FREEDOM
  c misc: --no_exceptions
  c include: .;supervisor/src;include;lib;;startup;lib/device;lib/drivers;lib/hal;generated/clad/robot;generated;.\supervisor\src;hal
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .\scatter.scf
  link misc: --remove
  group hal
    ./hal/: camera.cpp i2c.cpp timer.cpp enjpeg.cpp dac.cpp oled.cpp spi.cpp uart.cpp debug.cpp wifi.cpp imu.cpp motors.cpp lights.cpp spine.cpp watchdog.cpp power.cpp crashlogger.cpp fcc.cpp bootupdate.cpp
  group startup
    startup/: startup_MK02F12810.s
    ./hal/: bootupdate.s
  group clad
    ./generated/clad/: clad.cpp
software components: CMSIS:CORE 5.0.0
