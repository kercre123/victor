# Keil uVision project robot_boot_upgrade.uvprojx, settings and files
target robot (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MK02FN128xxx10 Freescale
  pack: Keil.Kinetis_K00_DFP.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x02000) IRAM2(0x1FFFE000,0x02000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robot_recover
  AfterMake: python tools\boot_header.py build\recover\robot_recover.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: TARGET_K02,COZMO_ROBOT,COZMO_ROBOT_V41,ROBOT_HARDWARE,CORETECH_ROBOT,DEBUG, CPU_MK02FN128VLH10, KEIL, FRDM_K22F120M, FREEDOM
  c misc: --no_exceptions
  c include: .;supervisor/src;include;k02_hal/lib;k02_hal/;k02_hal/startup;k02_hal/lib/device;k02_hal/lib/drivers;k02_hal/lib/hal;generated/clad/robot;.\supervisor\src;k02_hal/hal
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .\k02_hal\scatter.scf
  link misc: --remove
  group hal
    ./recover/: main.cpp image.s
  group startup
    k02_hal/startup/: startup_MK02F12810.s startup.c
software components: CMSIS:CORE 5.0.0
