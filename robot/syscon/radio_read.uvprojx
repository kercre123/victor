# Keil uVision project radio_read.uvprojx, settings and files
target syscon (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: syscon +hex
  BeforeMake: bash -c "make -C .. nrf"
  AfterMake: bash -c "make -C .. nrf_fix"
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1
  c define: NRF51,COZMO_ROBOT,SOFTDEVICE_PRESENT,BLE_STACK_SUPPORT_REQD
  c misc: --gnu
  c include: ./components/device;./components/drivers_nrf/hal;./components/libraries/util/;./components/drivers_nrf/config/;./components/drivers_nrf/common/;./components/drivers_nrf/rng;./components/softdevice/common/softdevice_handler;./components/softdevice/s110/headers;./components/ble/common;./components/ble/ble_services/ble_bas;./components/ble/ble_services/ble_dis;./components/ble/ble_advertising;../include;.;./components/libraries/trace;./components/drivers_nrf/pstorage;./components/drivers_nrf/pstorage/config;./components/ble/device_manager;./components/ble/device_manager/config;./components/libraries/timer;./components/softdevice/s110/headers;./components/ble/ble_services/ble_bps;../generated/clad/robot;./crypto;./hal;./cubes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group hal
    ./radio_test/: radio_tester.cpp
  group lib
    ./hal/: startup_nrf51.s
    ./lib/: system_nrf51.c
software components: CMSIS:CORE 4.1.0
