# Keil uVision project sys_upgrade.uvprojx, settings and files
target syscon (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: sys_upgrade
  BeforeMake: .\export_roms.cmd
  AfterMake: python ../tools/sign.py ./build/upgrade/sys_upgrade.axf ../releases/sys_upgrade.safe
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1
  c define: NRF51,COZMO_ROBOT
  c include: ./components/device;./components/drivers_nrf/hal;../include;.
  asm include: .
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0x1f000
  memory RVCT9: RAM 0x20000004 size 0x4000
  scatter file: .\upgrade.sct
  group upgrade
    ./upgrade/: main.cpp startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 4.1.0
