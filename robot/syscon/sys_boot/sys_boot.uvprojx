# Keil uVision project sys_boot.uvprojx, settings and files
target syscon (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: sys_boot.out
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1
  c define: NRF51,COZMO_ROBOT
  c include: .\lib\Include;.\lib\Include\app_common;.\lib\Include\ble;.\lib\Include\ble\ble_services;.\lib\Include\ble\rpc;.\lib\Include\gcc;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\scatter.scf
  group hal
    ./hal/: main.cpp sha1.cpp timer.cpp recovery.cpp
  group lib
    ./lib/: system_nrf51.c
  group startup
    ./startup/: startup_nrf51.s
software components: CMSIS:CORE 4.1.0
