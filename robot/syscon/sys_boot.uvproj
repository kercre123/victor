# Keil uVision project sys_boot.uvproj, settings and files
target sys_boot (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: sys_boot +hex
  AfterMake: fromelf --bin build\boot\sys_boot.axf --output build\boot\sys_boot.bin
  c flags: Optim=3 oTime=1 OneElfS=1
  c define: NRF51,COZMO_ROBOT
  c include: ./components/device;./components/toolchain;./components/drivers_nrf/hal;../include;.;./components/softdevice/s110/headers;../../crypto
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x1000
  memory RVCT9: RAM 0x20000008 size 0x3ff8
  group boot
    ./boot/: battery.cpp main.cpp recovery.cpp timer.cpp startup_nrf51.s lights.cpp
    ../../crypto/: crc32.cpp
  group lib
    ./lib/: system_nrf51.c
