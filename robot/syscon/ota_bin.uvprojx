# Keil uVision project ota_bin.uvprojx, settings and files
target ota_bin (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ota_bin
  AfterMake: fromelf --bin build\ota\ota_bin.axf --output build\ota\ota_bin.raw
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF51
  c include: ./components/toolchain;./components/drivers_nrf/hal;./components/device;../include;../../crypto;.;../generated;./ota;./hal
  library: MicroLIB
  memory RVCT4: ROM 0x20002000 size 0x800
  memory RVCT9: RAM 0x20002800 size 0x1800
  scatter file: .\ota\ota_bin.sct
  group ota
    ./ota/: ota.cpp ota.h startup_nrf51.s lights.cpp
  group crypto
    ../../crypto/: crc32.cpp
software components: CMSIS:CORE 4.3.0
