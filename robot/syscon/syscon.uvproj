# Keil uVision project syscon.uvproj, settings and files
target syscon (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: syscon +hex
  BeforeMake: bash -c "make -C .. nrf"
  AfterMake: bash -c "make -C .. safe"
  c flags: Optim=3 oTime=1 OneElfS=1
  c define: NRF51,COZMO_ROBOT,SOFTDEVICE_PRESENT,BLE_STACK_SUPPORT_REQD
  c misc: --gnu
  c include: ./components/device;./components/toolchain;./components/drivers_nrf/hal;./components/libraries/util/;./components/drivers_nrf/config/;./components/drivers_nrf/common/;./components/drivers_nrf/rng;./components/softdevice/common/softdevice_handler;./components/softdevice/s110/headers;./components/ble/common;./components/ble/ble_services/ble_bas;./components/ble/ble_services/ble_dis;./components/ble/ble_advertising;../include;.;./components/libraries/trace;./components/drivers_nrf/pstorage;./components/drivers_nrf/pstorage/config;./components/ble/device_manager;./components/ble/device_manager/config;./components/libraries/timer;./components/softdevice/s110/headers;./components/ble/ble_services/ble_bps;../generated/clad/robot;./crypto
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x7000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group hal
    ./hal/: battery.cpp debug.cpp head.cpp main.cpp micro_esb.cpp motors.cpp radio.cpp rtos.cpp tests.cpp timer.cpp logging.cpp backpack.cpp lights.cpp messages.cpp storage.cpp
  group lib
    ./hal/: startup_nrf51.s
    ./lib/: system_nrf51.c
  group ble
    ./hal/: bluetooth.cpp app_timer.cpp settings.c
    ./components/ble/common/: ble_advdata.c ble_conn_params.c
  group clad
    ../generated/clad/: clad.cpp
  group crypto
    ./hal/: crypto.cpp
    ./crypto/: bignum.cpp sha1.cpp aes.cpp
  group bootloader
    ./hal/: bootloader.cpp bootbin.s
