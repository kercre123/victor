# Keil uVision project robot_sideload.uvprojx, settings and files
target sideload (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MK02FN128xxx10 Freescale
  pack: Keil.Kinetis_K00_DFP.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x02000) IRAM2(0x1FFFE000,0x02000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robot_sideload +hex
  AfterMake: fromelf --bin build\sideload\robot_sideload.axf --output binaries\robot_sideload.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: COZMO_ROBOT,COZMO_ROBOT_V41,ROBOT_HARDWARE,CORETECH_ROBOT,DEBUG, CPU_MK02FN128VLH10, KEIL, FRDM_K22F120M, FREEDOM
  c misc: --library_type=standardlib --diag_suppress=1296,186 
 --library_interface=armcc  
--gnu
  c include: k02_hal/lib;include;k02_hal;../crypto;k02_hal/hal
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .\sideload\sideload.sct
  link misc: --remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x400"
  group sideload
    ./sideload/: main.cpp calltable.s
    ../crypto/: bignum.cpp crc32.cpp rsa_pss.cpp sha1.cpp sha512.cpp
software components: CMSIS:CORE 4.1.0
