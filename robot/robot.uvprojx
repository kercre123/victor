# Keil uVision project robot.uvprojx, settings and files
target robot (ARM-ADS)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robot
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE,STM32F40_41xxx,COZMO_ROBOT,ROBOT_HARDWARE,CORETECH_ROBOT,OFFBOARD_VISION
  c misc: --asm
  c include: .\arm_hal;.\arm_hal\lib;..\include;..\coretech\common\include;..\coretech\messaging\include;..\coretech\planning\include;..\coretech\vision\include;.\supervisor\src;..\..\coretech-external\heatshrink;C:\Keil\ARM\Pack\ARM\CMSIS\3.20.4\Device\ARM\ARMCM4\Include;.\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20004100 size 0x1bf00
  group hal
    ../include/anki/cozmo/robot/: hal.h
    ./arm_hal/hal/: imu.cpp lights.cpp main.cpp motors.cpp retarget.cpp spi.cpp startup.cpp timer.cpp uart.cpp usb_radio.cpp system_stm32f4xx.c
  group lib
    ./arm_hal/lib/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group startup
    ./arm_hal/startup/: startup_stm32f429_439xx.s
  group supervisor
    ./supervisor/src/: cozmoBot.cpp dockingController.cpp gripController.cpp headController.cpp liftController.cpp localization.cpp messages.cpp pathFollower.cpp pickAndPlaceController.cpp speedController.cpp steeringController.cpp testModeController.cpp visionDebugStream.cpp visionParameters.h visionParameters.cpp wheelController.cpp imuFilter.cpp animationController.cpp proxSensors.cpp faceTrackingController.cpp eyeController.cpp animation.cpp keyFrame.cpp offboardVisionSystem.cpp
  group coretech-common
    ../coretech/common/robot/src/: array2d.cpp benchmarking.cpp comparisons.cpp compress.cpp decisionTree.cpp draw.cpp errorHandling.cpp find.cpp fixedLengthList.cpp flags.cpp geometry.cpp interpolate.cpp matlabInterface.cpp matrix.cpp memory.cpp opencvLight.cpp sequences.cpp serialize.cpp trig_fast.cpp utilities.cpp utilities_c.c
    ../coretech/common/shared/src/: radians.cpp utilities_shared.cpp velocityProfileGenerator.cpp matlabConverters.cpp
    ../coretech/vision/robot/src/: perspectivePoseEstimation.cpp
  group coretech-planning
    ../coretech/planning/shared/src/: path.cpp
  group embedded-tests
    ./test/: embeddedCommonTests.cpp embeddedTests.cpp embeddedTests.h embeddedVisionTests.cpp run_m4_embeddedTests.cpp
target embedded-tests (ARM-ADS)
  device: STM32F429NI STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: robot
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_DEFAULT_TIMEOUT_CALLBACK,USE_EMBEDDED_PHY,USE_USB_OTG_FS,COZMO_ROBOT,ROBOT_HARDWARE,ANKICORETECH_EMBEDDED_USE_HEATSHRINK,CORETECH_ROBOT
  c misc: --asm
  c include: as above
  memory RVCT4: ROM 0x0 size 0xa
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\robot.sct
