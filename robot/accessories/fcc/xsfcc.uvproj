# Keil uVision project xsfcc.uvproj, settings and files
target nRF31512 (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: xsfcc +hex
  AfterMake: ..\..\crypto\hex2bin build\xsfcc.hex
  c flags: Optimize=9
  c include: ..\_include
  group hal
    ./: main.c lights.c radio.c
