# Keil uVision project robot_boot.uvproj, settings and files
target robot (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: robot_boot
  AfterMake: fromelf --bin build\robot_boot.axf --output build\robot_boot.bin
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: COZMO_ROBOT,COZMO_ROBOT_V41,ROBOT_HARDWARE,CORETECH_ROBOT,DEBUG, CPU_MK02FN128VLH10, KEIL, FRDM_K22F120M, FREEDOM
  c misc: --library_type=standardlib --diag_suppress=1296,186 
 --library_interface=armcc  
--gnu
  c include: .;include;lib;startup;lib/device;lib/drivers;lib/hal;..;hal
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  scatter file: .\scatter.scf
  link misc: --remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x400"
  group hal
    ./hal/: main.cpp timer.cpp sha1.cpp recovery.cpp power.cpp
  group startup
    ./startup/: startup.c startup_MK02F12810.s system_MK02F12810.c
