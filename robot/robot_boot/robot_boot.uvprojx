# Keil uVision project robot_boot.uvprojx, settings and files
target robot (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MK02FN128xxx10 Freescale
  pack: Keil.Kinetis_K00_DFP.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x02000) IRAM2(0x1FFFE000,0x02000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robot_boot +hex
  AfterMake: fromelf --bin build\robot_boot.axf --output build\robot_boot.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: COZMO_ROBOT,COZMO_ROBOT_V41,ROBOT_HARDWARE,CORETECH_ROBOT,DEBUG, CPU_MK02FN128VLH10, KEIL, FRDM_K22F120M, FREEDOM
  c misc: --library_type=standardlib --diag_suppress=1296,186 
 --library_interface=armcc  
--gnu
  c include: .;include;lib;startup;lib/device;lib/drivers;lib/hal;..;hal
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  link misc: --remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x400"
  group hal
    ./hal/: main.cpp timer.cpp recovery.cpp power.cpp fconf.cpp spi.cpp sha1.cpp
  group startup
    ./startup/: startup.c startup_MK02F12810.s system_MK02F12810.c
software components: CMSIS:CORE 4.1.0
