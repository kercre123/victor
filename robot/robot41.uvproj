# Keil uVision project robot41.uvproj, settings and files
target robot (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: robot.out
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: COZMO_ROBOT,ROBOT_HARDWARE,CORETECH_ROBOT,DEBUG, CPU_MK02FN128VLH10, KEIL, FRDM_K22F120M, FREEDOM
  c misc: --library_type=standardlib --diag_suppress=1296,186 
 --library_interface=armcc
  c include: .;supervisor/src;../coretech/common/include;../coretech/vision/include;../include;include;k02_hal/lib;k02_hal/;k02_hal/startup
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  scatter file: .\k02_hal\scatter.scf
  link misc: --remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x400"
  group hal
    k02_hal/hal/: main.cpp
    ./k02_hal/hal/: camera.cpp i2c.cpp timer.cpp enjpeg.cpp power.cpp debug.cpp dac.cpp uart.cpp spi.cpp
  group startup
    k02_hal/startup/: startup_MK02F12810.s system_MK02F12810.c startup.c
