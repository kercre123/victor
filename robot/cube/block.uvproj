# Keil uVision project block.uvproj, settings and files
target block (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODDP2
  output: cube +hex
  AfterMake: hex2bin build\cube.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\compiler\c51;.\compiler\common;.\hal;.\nordic_hal;.\nordic_hal\nrf24l01p;.\nordic_hal\nrf24le1
  group application
    ./hal/: main.c
  group hal
    ./hal/: accel.c lights.c tests.c radio.c uart.c simple_string.c
  group nordic_hal
    ./nordic_hal/: hal_delay.c
    ./nordic_hal/nrf24l01p/: hal_nrf.c
    ./nordic_hal/nrf24le1/: hal_clk.c hal_nrf_hw.c hal_uart.c
