# Keil uVision project cube_application.uvprojx, settings and files
target cube_application (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: cube_application
  AfterMake: fromelf --bin Objects\cube_application.axf --output Objects\cube_application.bin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --thumb -c --bss_threshold=0
  c include: ./sdk/platform/driver/gpio;./sdk/platform/arch/;./sdk/platform/arch/compiler/rvds/;./sdk/platform/arch/ll/rvds/;./sdk/platform/include/;./sdk/platform/driver/reg/
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app\application.sct
  group src
    ./app/: boot.s main.c board.c
  group sdk
    ./sdk/platform/driver/gpio/: gpio.c
software components: CMSIS:CORE 5.0.1
