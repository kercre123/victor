# Keil uVision project vicfix.uvproj, settings and files
target Debug (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: vicfix +hex
  BeforeMake: cmd /c del build\binaries.o
  AfterMake: fromelf --bin build\vicfix.axf --output build\vicfix.bin
  AfterMake: crypto\Release_FIXTURE\makesafe_fixture -prod fixture.safe build\vicfix.bin
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: FIXTURE,STM32F2XX,USE_STDPERIPH_DRIVER,DEBUG
  c misc: --exceptions --exceptions_unwind
  c include: .;app;common;hal;inc;lib;stm32f2xx;tests;xxx
  asm misc: --cpreproc
  memory RVCT4: ROM 0x8060000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\vicfix.sct
  link misc: --datacompressor off
  group app
    ./app/: app.cpp binaries.s binariesc.c fixture.cpp cmd.cpp
  group tests
    ./tests/: TestBody.cpp TestCommon.cpp TestHead.cpp TestBackpack.cpp TestCube.cpp TestRobot.cpp TestMotor.cpp TestDebugStub.cpp TestDebugHelper.cpp
  group lib
    ./lib/: crc16.c nvReset.c swd.cpp swd_stm32.cpp swd_da1458x.cpp
  group hal
    ./hal/: board.cpp bpled.cpp system_stm32f2xx.c startup_stm32f2xx.s stm32fxxx_it.c display.c display_dummy.c flash.c console.c meter.cpp cube.c testport.c motorled.c random.c psk.c dut_uart.cpp
    ./common/: contacts.cpp timer.cpp
  group stm32f2xx
    ./stm32f2xx/: misc.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_tim.c stm32f2xx_pwr.c stm32f2xx_usart.c stm32f2xx_spi.c stm32f2xx_dma.c stm32f2xx_adc.c
  group crypto
    ./crypto/: opensafe.c
