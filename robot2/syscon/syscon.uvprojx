# Keil uVision project syscon.uvprojx, settings and files
target syscon (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: syscon +hex
  BeforeMake: python ./tools/message-buffers/emitters/CPPLite_emitter.py  ./schema/messages.clad -r build -o build
  AfterMake: python ./tools/sign.py -b build\@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030X8
  c misc: --gnu
  c include: common;build
  memory RVCT4: ROM 0x8002000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\src\syscon.sct
  group src
    ./src/: comms.cpp encoders.cpp main.cpp motors.cpp timer.cpp power.cpp contacts.cpp vectors.s opto.cpp analog.cpp lights.cpp mics.cpp touch.cpp
    ./common/: flash.cpp
software components: CMSIS:CORE 5.0.1
