# Keil uVision project diag.uvproj, settings and files
target robot (ARM-ADS)
  device: STM32F439NI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: robot
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_DEFAULT_TIMEOUT_CALLBACK,USE_EMBEDDED_PHY,USE_USB_OTG_FS,COZMO_ROBOT,ROBOT_HARDWARE,ANKICORETECH_EMBEDDED_USE_HEATSHRINK,CORETECH_ROBOT
  c misc: --asm
  c include: ..\..\include;..\arm_hal;..\arm_hal\lib;..\include;..\..\coretech\common\include;..\..\coretech\messaging\include;..\coretech\planning\include;..\coretech\vision\include;.\supervisor\src;..\..\coretech-external\heatshrink;C:\Keil\ARM\Pack\ARM\CMSIS\3.20.4\Device\ARM\ARMCM4\Include;.\include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0xc0000000 size 0x800000
  memory RVCT9: RAM 0x20004100 size 0x2bf00
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\diag.sct
  group hal
    ../arm_hal/hal/: frontCamera.cpp motors.cpp retarget.cpp spi.cpp startup.cpp timer.cpp uart.cpp imu.cpp
    ./: diag_main.cpp audio.cpp led.cpp
  group lib
    ../arm_hal/lib/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c
  group startup
    ../arm_hal/startup/: startup_stm32f429_439xx.s
  group coretech
    ../../coretech/common/robot/src/: utilities_c.c
target embedded-tests (ARM-ADS)
  device: STM32F429NI STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: robot
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: as above
  c misc: --asm
  c include: ..\include;..\..\include;..\arm_hal;..\arm_hal\lib;C:\Keil\ARM\Pack\ARM\CMSIS\3.20.4\Device\ARM\ARMCM4\Include;..\..\coretech\common\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0xc0000000 size 0x400000
  memory RVCT9: RAM 0x20004100 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
