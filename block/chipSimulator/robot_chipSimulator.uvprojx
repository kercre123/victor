# Keil uVision project robot_chipSimulator.uvprojx, settings and files
target embedded-tests-chipSimulator (ARM-ADS)
  device: ARMCM4 ARM
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(10000000) ELITTLE
  output: robot_chipSimulator
  c flags: Optim=3 oTime=1 wLevel=2
  c define: COZMO_ROBOT,ROBOT_HARDWARE,ANKICORETECH_EMBEDDED_USE_HEATSHRINK,USING_CHIP_SIMULATOR
  c misc: --asm
  c include: ..\arm_hal;..\arm_hal\lib;..\..\include;..\..\coretech\common\include;..\..\coretech\messaging\include;..\..\coretech\planning\include;..\..\coretech\vision\include;..\supervisor\src;..\..\..\coretech-external\heatshrink;C:\Keil\ARM\Pack\ARM\CMSIS\3.20.4\Device\ARM\ARMCM4\Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0xc0000000 size 0x400000
  memory RVCT9: RAM 0x20004100 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group hal
    ./: main_simulator.cpp Retarget.c
  group coretech-common
    ../../coretech/common/robot/src/: array2d.cpp benchmarking_c.c comparisons.cpp compress.cpp draw.cpp errorHandling.cpp find.cpp fixedLengthList.cpp flags.cpp geometry.cpp interpolate.cpp matlabConverters.cpp matlabInterface.cpp matrix.cpp memory.cpp opencvLight.cpp sequences.cpp serialize.cpp trig_fast.cpp utilities.cpp utilities_c.c decisionTree.cpp
  group coretech-external
    ../../../coretech-external/heatshrink/: heatshrink_decoder.cpp heatshrink_encoder.cpp
  group coretech-vision
    ../../coretech/vision/robot/src/: binaryTracker.cpp computeCharacteristicScale.cpp computeQuadrilaterals.cpp connectedComponents.cpp docking_vision.cpp draw_vision.cpp edgeDetection.cpp fiducialMarkers.cpp filtering.cpp integralImage.cpp laplacianPeaks.cpp traceBoundary.cpp transformations.cpp colorConversion.cpp decisionTree_vision.cpp detectFiducialMarkers.cpp histogram.cpp lucasKanade_Affine.cpp lucasKanade_Fast.cpp lucasKanade_General.cpp lucasKanade_Projective.cpp lucasKanade_SampledProjective.cpp lucasKanade_Slow.cpp
  group embedded-tests
    ../test/: embeddedCommonTests.cpp embeddedTests.cpp embeddedVisionTests.cpp run_m4_embeddedTests.cpp
  group ::CMSIS
    C:/Keil/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group ::Device
    RTE/Device/ARMCM4/: startup_ARMCM4.s system_ARMCM4.c
software components: CMSIS:CORE 3.20.0, CMSIS:DSP 1.4.1, Device:Startup 0.0.1
