# Keil uVision project block.uvproj, settings and files
target block (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODDP2
  output: block +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\hal\nrf24le1;..\..\..\..\compiler\c51;..\..\..\..\compiler\common;..\..\..\..\hal;..\..\..\..\hal\nrf24l01p
  group application
    ../: main.c
  group hal
    ../../../../hal/nrf24le1/: hal_clk.c hal_nrf_hw.c
    ../../../../hal/nrf24l01p/: hal_nrf.c
    ./: lights.c accel.c
    ../../../../hal/: hal_delay.c
